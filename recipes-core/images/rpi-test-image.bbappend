require rpi-test-image-packages.inc
require rpi-test-image-network.inc
require rpi-test-image-docker.inc
require rpi-test-image-selfcheck.inc
require rpi-test-image-output.inc